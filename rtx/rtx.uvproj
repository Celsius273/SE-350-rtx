# Keil uVision project rtx.uvproj, settings and files
target RTX SIM (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: rtx
  c define: NDEBUG _DEBUG_HOTKEYS HAS_TIMESLICING
  c misc: --c99 --gnu -Ospace
  memory RVCT4: ROM 0x10000000 size 0x4000
  memory RVCT9: RAM 0x10004000 size 0x4000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./src/: startup_LPC17xx.s
  group System Code
    ./src/: system_LPC17xx.c uart_polling.c printf.c main_svc.c uart_irq.c kcd.c sys_proc.c crt.c
  group RTX Kernel Code
    ./src/: HAL.c k_rtx_init.c k_memory.c k_process.c list.c priority_queue.c timer.c message_queue.c
  group User Code
    ./src/: usr_proc.c
  group Documentation
    ./: Abstract.txt
